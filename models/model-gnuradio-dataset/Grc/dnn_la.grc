options:
  parameters:
    author: gt
    generate_options: qt_gui
    id: top_block_2
    output_language: python
    realtime_scheduling: '1'
    title: Loopback Transmitter
  states: {}

blocks:
- name: frame_numSymbols
  id: variable
  parameters:
    value: '4'
  states: {}
- name: frame_preambleLength
  id: variable
  parameters:
    value: '256'
  states: {}
- name: gfdm_K
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: gfdm_M
  id: variable
  parameters:
    value: '4'
  states: {}
- name: gfdm_N
  id: variable
  parameters:
    value: 2048*4
  states: {}
- name: gfdm_NCP
  id: variable
  parameters:
    value: '128'
  states: {}
- name: gfdm_NCS
  id: variable
  parameters:
    value: '64'
  states: {}
- name: gfdm_NW
  id: variable
  parameters:
    value: '32'
  states: {}
- name: gfdm_a
  id: variable
  parameters:
    value: '0'
  states: {}
- name: gfdm_symbolLen
  id: variable
  parameters:
    value: (2048*4)+128+64
  states: {}
- name: headroom
  id: variable
  parameters:
    value: '1.0'
  states: {}
- name: high_low
  id: variable
  parameters:
    comment: |-
      Set to zero to TX RX Loopback
      {+1, 0, -1}
    value: '0'
  states: {}
- name: mcs_mode
  id: variable
  parameters:
    value: '0'
  states: {}
- name: mpattern
  id: variable
  parameters:
    value: scmux.maxPattern
  states: {}
- name: mux_activeSubCarries
  id: variable
  parameters:
    value: np.concatenate((  np.repeat(1, np.ceil(nactive/2)), np.repeat(0, gfdm_K-nactive )  , np.repeat(1, np.floor(nactive/2))  )).astype(int)
  states: {}
- name: mux_framePattern
  id: variable
  parameters:
    value: np.concatenate((0*np.ones(frame_preambleLength) ,1*np.ones(gfdm_symbolLen*frame_numSymbols) ),0).astype(int)
  states: {}
- name: mux_pilotSpacing
  id: variable
  parameters:
    value: '4'
  states: {}
- name: mux_pilotTimeSpacing
  id: variable
  parameters:
    value: '4'
  states: {}
- name: nactive
  id: variable
  parameters:
    comment: Must be multiple of pilot spacing
    value: 1536+12
  states: {}
- name: pilots
  id: variable
  parameters:
    value: inatel5g.get_zadoffChu(scmux.pilotLen,7)
  states: {}
- name: preamble
  id: variable
  parameters:
    value: inatel5g.get_preamble(frame_preambleLength,gfdm_K,nactive )
  states: {}
- name: ref_sep
  id: variable
  parameters:
    value: 30e6
  states: {}
- name: rf_freq
  id: variable
  parameters:
    value: 2100e6
  states: {}
- name: root
  id: variable
  parameters:
    value: '1'
  states: {}
- name: rx_freq
  id: variable
  parameters:
    value: 2100e6
  states: {}
- name: rx_offset
  id: variable
  parameters:
    value: '61440000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '30720000'
  states: {}
- name: scmux
  id: variable
  parameters:
    value: inatel5g.get_SubcarrierPattern(gfdm_K,gfdm_M,nactive,mux_pilotSpacing, mux_pilotTimeSpacing,frame_numSymbols)
  states: {}
- name: snr
  id: variable_qtgui_range
  parameters:
    start: '-10'
    step: '0.1'
    stop: '40'
    value: '24.2'
  states: {}
- name: syncref
  id: variable
  parameters:
    value: np.conj(np.flipud(preamble))
  states: {}
- name: tx_freq
  id: variable
  parameters:
    value: 2100e6
  states: {}
- name: tx_mcs
  id: variable
  parameters:
    value: '13'
  states: {}
- name: tx_offset
  id: variable
  parameters:
    value: '61440000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: complex
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: 0.78*np.sqrt(gfdm_K/float(nactive))
    noise_type: analog.GR_GAUSSIAN
    samples: int(30e6)+1
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '60000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: pow(10,((-1.0*snr)/20.0))
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_source_1
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_patterned_interleaver_0
  id: blocks_patterned_interleaver
  parameters:
    pattern: scmux.sc_pattern.tolist()
    type: complex
  states: {}
- name: blocks_probe_rate_1
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '1000.0'
    type: complex
  states: {state: disabled}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: ''
    mtu: scmux.dataLen
    port: '52001'
    tcp_no_delay: 'True'
    type: TCP_SERVER
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: pilots/headroom
  states: {}
- name: deepSnrEstimation_discard_control_0
  id: deepSnrEstimation_discard_control
  parameters:
    num_qam: scmux.dataLen
  states: {}
- name: epy_block_0_2
  id: epy_block
  parameters:
    _source_code: "import pmt\nimport numpy as np\nimport tensorflow as tf\nfrom gnuradio import gr\nfrom tensorflow.python.ops.numpy_ops import np_config\nfrom sklearn import preprocessing\nfrom keras.models import model_from_json\nfrom numba import jit\n\nMOD_QPSK = 0\nMOD_16_QAM = 1\nMOD_64_QAM = 2\nMOD_256_QAM = 3\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    def __init__(self, dnn_dis=0.0):  # DNN disable parameter\n        gr.sync_block.__init__(\n            self,\n            name='SINR Estimation-DNN',   # will show up in GRC\n            in_sig=[np.complex64],\n            out_sig=[np.float32, np.float32]\n        )\n\n        gpus = tf.config.list_physical_devices('GPU')\n        if gpus:\n                try:\n    \t\t\t# Currently, memory growth needs to be the same across GPUs\n                        for gpu in gpus:\n                                tf.config.experimental.set_memory_growth(gpu, True)\n                        logical_gpus = tf.config.list_logical_devices('GPU')\n                        print(len(gpus), \"Physical GPUs,\", len(logical_gpus), \"Logical GPUs\")\n                except RuntimeError as e:\n                        # Memory growth must be set before GPUs have been initialized\n                        print(e)\n        self.mcs = 0\n        self.mcs_d = 0\n        self.mcs_control = 0\n        self.mcs_control_d = 0\n        self.modul = 0\n        self.modul_d = 0\n        self.message_port_register_in(pmt.intern('msg_in'))\n        self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)\n        self.message_port_register_out(pmt.intern('mcs'))\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        self.dnn_dis = dnn_dis\n        self.key = pmt.intern(\"set_tx_mcs\")\n        self.mcs_table = (5.5 + 1.5, 6.5 + 1.5, 7.0 + 1.5, 8.0 + 1.5, 12.0 + 1.5, 13.0 + 1.5, 14.0 + 1.5,\\\n\t\t14.5 + 1.5, 18.5 + 1.5, 19.5 + 1.5, 20.0 + 1.5, 25.5 + 1.5, 26.5 + 1.5, 27.5 + 1.5)\n        self.mcs_max = 13\n        self.mse = 20\n        self.snr_adapt = 20\n\n        # Preraring dataset\n        X_l = np.loadtxt(\"measured_qpsk.csv\")\n        y_l = np.loadtxt(\"diff_qpsk.csv\")\n        X = X_l[300:800]\n        y = y_l[300:800]\n\n        self.X_scaler_qpsk = preprocessing.MinMaxScaler(feature_range=(0, 1))\n        self.y_scaler_qpsk = preprocessing.MinMaxScaler(feature_range=(0, 1))\n        self.X_scaler_qpsk.fit(X.reshape(-1,1))\n        self.y_scaler_qpsk.fit(y.reshape(-1,1))\n\n        X_l = np.loadtxt(\"measured_16qam.csv\")\n        y_l = np.loadtxt(\"diff_16qam.csv\")\n        X = X_l[300:800]\n        y = y_l[300:800]\n\n        self.X_scaler_16 = preprocessing.MinMaxScaler(feature_range=(0, 1))\n        self.y_scaler_16 = preprocessing.MinMaxScaler(feature_range=(0, 1))\n        self.X_scaler_16.fit(X.reshape(-1,1))\n        self.y_scaler_16.fit(y.reshape(-1,1))\n\n        X_l = np.loadtxt(\"measured_64qam.csv\")\n        y_l = np.loadtxt(\"diff_64qam.csv\")\n        X = X_l[300:800]\n        y = y_l[300:800]\n\n        self.X_scaler_64 = preprocessing.MinMaxScaler(feature_range=(0, 1))\n        self.y_scaler_64 = preprocessing.MinMaxScaler(feature_range=(0, 1))\n        self.X_scaler_64.fit(X.reshape(-1,1))\n        self.y_scaler_64.fit(y.reshape(-1,1))\n\n        X_l = np.loadtxt(\"measured_256qam.csv\")\n        y_l = np.loadtxt(\"diff_256qam.csv\")\n        X = X_l[300:800]\n        y = y_l[300:800]\n\n        self.X_scaler_256 = preprocessing.MinMaxScaler(feature_range=(0, 1))\n        self.y_scaler_256 = preprocessing.MinMaxScaler(feature_range=(0, 1))\n        self.X_scaler_256.fit(X.reshape(-1,1))\n        self.y_scaler_256.fit(y.reshape(-1,1))\n\n        # load json and created models\n        self.json_file = open('model_qpsk_146d.json', 'r')\n        self.model_qpsk_json = self.json_file.read()\n        self.json_file.close()\n        self.model_qpsk = model_from_json(self.model_qpsk_json)\n        # load weights into new model\n        self.model_qpsk.load_weights(\"model_qpsk_146d.h5\")\n\n        # load json and created models\n        self.json_file = open('model_16qam_146d.json', 'r')\n        self.model_16_json = self.json_file.read()\n        self.json_file.close()\n        self.model_16 = model_from_json(self.model_16_json)\n        # load weights into new model\n        self.model_16.load_weights(\"model_16qam_146d.h5\")\n\n        # load json and created models\n        self.json_file = open('model_64qam_146d.json', 'r')\n        self.model_64_json = self.json_file.read()\n        self.json_file.close()\n        self.model_64 = model_from_json(self.model_64_json)\n        # load weights into new model\n        self.model_64.load_weights(\"model_64qam_146d.h5\")\n\n        # load json and created models\n        self.json_file = open('model_256qam_146d.json', 'r')\n        self.model_256_json = self.json_file.read()\n        self.json_file.close()\n        self.model_256 = model_from_json(self.model_256_json)\n        # load weights into new model\n        self.model_256.load_weights(\"model_256qam_146d.h5\")\n\n        # Default configuration\n        self.X_scaler = self.X_scaler_qpsk\n        self.y_scaler = self.y_scaler_qpsk\n        self.max_value = np.float32(2.0)\n        self.factor = np.float32(1.414213562)\n        self.beta = np.float32(1.0)\n\n    def handle_msg(self, msg_pmt):\n        set_rx_mcs = pmt.intern(\"MCS\")\n        if (pmt.car(msg_pmt) == set_rx_mcs):\n                msg = pmt.cdr(msg_pmt)\n                #print (msg)\n                self.mcs_d = self.mcs\n                self.mcs = pmt.to_python(msg)\n        if self.mcs == self.mcs_d:\n                return\n        #self.mcs = 10\n        if self.mcs < 4:\n                self.modul_d = self.modul\n                self.modul = MOD_QPSK\n        elif self.mcs < 8:\n                self.modul_d = self.modul\n                self.modul = MOD_16_QAM\n        elif self.mcs < 11:\n                self.modul_d = self.modul\n                self.modul = MOD_64_QAM\n        elif self.mcs < 14:\n                self.modul_d = self.modul\n                self.modul = MOD_256_QAM\n        if self.modul == self.modul_d:\n                return\n        if self.modul == MOD_QPSK:\n                self.X_scaler = self.X_scaler_qpsk\n                self.y_scaler = self.y_scaler_qpsk\n                self.max_value = np.float32(2.0)\n                self.factor = np.float32(1.414213562)\n                self.beta = np.float32(1.0)\n                #print (\"***** config DNN: QPSK *****\")\n        elif self.modul == MOD_16_QAM:\n                self.X_scaler = self.X_scaler_16\n                self.y_scaler = self.y_scaler_16\n                self.max_value = np.float32(4.0)\n                self.factor = np.float32(3.16227766)\n                self.beta = np.float32(2.0)\n                #print (\"***** config DNN: 16QAM *****\")\n        elif self.modul == MOD_64_QAM:\n                self.X_scaler = self.X_scaler_64\n                self.y_scaler = self.y_scaler_64\n                self.max_value = np.float32(8.0)\n                self.factor = np.float32(6.4807407)\n                self.beta = np.float32(3.0)\n                #print (\"***** config DNN: 64QAM *****\")\n        elif self.modul == MOD_256_QAM:\n                self.X_scaler = self.X_scaler_256\n                self.y_scaler = self.y_scaler_256\n                self.max_value = np.float32(16.0)\n                self.factor = np.float32(13.038413)\n                self.beta = np.float32(4.0)\n                #print (\"***** config DNN: 256QAM *****\")\n    @jit \n    def mse_calc(self, N, complex_input):\n        max_value = self.max_value\n        factor = self.factor\n        beta = self.beta\n        mse = np.float32(0.0)\n        for i in range(N):\n            d_real = np.abs(np.real(complex_input[i]))*factor\n            d_imag = np.abs(np.imag(complex_input[i]))*factor\n\n            dec_real = np.round((d_real + 1.0)/2.0)*2.0 - 1.0\n            comp_real = np.float32(0.0)\n            if (d_real > max_value):\n                    dec_real = max_value - 1.0\n                    comp_real = np.abs(d_real - dec_real)\n            dec_imag = np.round((d_imag + 1.0)/2.0)*2.0 - 1.0\n            comp_imag = np.float32(0.0)\n            if (d_imag > max_value):\n                    dec_imag = max_value - 1.0\n                    comp_imag = np.abs(d_imag - dec_imag)\n            comp_real = beta*comp_real/factor\n            comp_imag = beta*comp_imag/factor\n            d_real = (d_real - dec_real)/factor\n            d_imag = (d_imag - dec_imag)/factor\n            mse = mse + d_real * d_real + d_imag * d_imag + comp_real * comp_real + comp_imag * comp_imag\n        return -10*np.log10(mse/N)\n    \n    @tf.function(jit_compile=True)\n    def predict_qpsk(self, x):\n        return self.model_qpsk(x)\n    \n    @tf.function(jit_compile=True)\n    def predict_16qam(self, x):\n        return self.model_16(x)\n    \n    @tf.function(jit_compile=True)\n    def predict_64qam(self, x):\n        return self.model_64(x)\n    \n    @tf.function(jit_compile=True)\n    def predict_256qam(self, x):\n        return self.model_256(x)\n\n#    @jit\n    def calc_error(self, snr):\n        x = np.zeros(shape=(1, 1), dtype=np.float32)\n        x[0] = (snr)\n        #print(f'X: {x}')\n        y = self.X_scaler.transform(x.reshape(-1, 1))\n        #print(f'X_SCALED: {y}')\n        if self.modul == MOD_QPSK:\n            pred = self.predict_qpsk(y)\n        elif self.modul == MOD_16_QAM:\n            pred = self.predict_16qam(y)\n        elif self.modul == MOD_64_QAM:\n            pred = self.predict_64qam(y)\n        elif self.modul == MOD_256_QAM:\n            pred = self.predict_256qam(y)\n        #print(f'PRED: {pred}')\n        scaled = self.y_scaler.inverse_transform(pred)\n        #print(f'SCALED: {scaled}')\n        return scaled\n\n    def work(self, input_items, output_items):\n        n = np.size(input_items[0])\n        self.snr_adapt += self.mse_calc(n, input_items[0][:]) - self.snr_adapt/64\n        snr_adapt_f = self.snr_adapt/64\n        dnn_comp = self.calc_error(snr_adapt_f) + snr_adapt_f\n        self.mse += dnn_comp - self.mse/64\n        mse_f = self.mse/64\n        if self.mcs_control > 0:\t\t\t\t# fallback test\n                if mse_f < self.mcs_table[self.mcs_control]:\n                        self.mcs_control -= 1\n        if self.mcs_control < (self.mcs_max):\t\t\t# fall forward test\n                if mse_f > (self.mcs_table[self.mcs_control+1] + 1.0):\n                        self.mcs_control += 1\n        if self.mcs_control_d != self.mcs_control:\n                self.mcs_control_d = self.mcs_control\n                val = pmt.from_long(self.mcs_control)\n                mcs_dict = pmt.make_dict()\n                mcs_dict = pmt.dict_add(mcs_dict, self.key, val)\n                self.message_port_pub(pmt.intern('mcs'), mcs_dict)\n        output_items[0][:] = mse_f\n        output_items[1][:] = snr_adapt_f\n        return len(output_items[0])\n\n"
    dnn_dis: '0.0'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import inatel5g
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: inatel5g_c_equalizer_0
  id: inatel5g_c_equalizer
  parameters:
    K: gfdm_K
    M: gfdm_M
    interp_type: '0'
    pattern: scmux.sc_pattern
    pilot_df: mux_pilotSpacing
    pilot_dt: mux_pilotTimeSpacing
    pilots: pilots
  states: {}
- name: inatel5g_gfdm_waveform_0
  id: inatel5g_gfdm_waveform
  parameters:
    K: gfdm_K
    M: gfdm_M
    NCP: gfdm_NCP
    NCS: gfdm_NCS
    NW: gfdm_NW
    alpha: gfdm_a
    mod_demod: 'True'
    num_inputs: '1'
  states: {}
- name: inatel5g_gfdm_waveform_1
  id: inatel5g_gfdm_waveform
  parameters:
    K: gfdm_K
    M: gfdm_M
    NCP: gfdm_NCP
    NCS: gfdm_NCS
    NW: gfdm_NW
    alpha: gfdm_a
    mod_demod: 'False'
    num_inputs: '1'
  states: {}
- name: inatel5g_search_header_0
  id: inatel5g_search_header
  parameters:
    header: '0xC01DBEEF'
  states: {}
- name: inatel5g_variable_deframer_cb_0
  id: inatel5g_variable_deframer_cb
  parameters:
    mcs: '0'
    num_qam: scmux.dataLen
  states: {}
- name: inatel5g_variable_framer_bc_0
  id: inatel5g_variable_framer_bc
  parameters:
    blocklen: scmux.dataLen
    buffersize: (2**25)
    mcs: tx_mcs
    mode: mcs_mode
    sync_len: len(mux_framePattern)
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    alpha1: '0.2'
    color1: '"red"'
    grid: 'True'
    gui_hint: 2,0,8,1
    name: '"Constelation"'
    size: sum(scmux.sc_pattern==1)
    tr_tag: '"eq_frame_start"'
    type: complex
    xmax: '+2'
    ymax: '+2'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '40'
    min: '-20'
    name: '"DNN SNR"'
    type: float
    update_time: '0.01'
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '40'
    min: '-20'
    name: '"MMSE SNR"'
    type: float
    update_time: '0.01'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    size: scmux.dataLen
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 2,1,8,1
    label1: '|H|'
    name: '"Channel Frequency Response"'
    srate: '1'
    type: msg_float
    ymax: '6'
    ymin: '-85'
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: tx0
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: rx_signal
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: recv_data
  states: {}
- name: virtual_sink_1_0_0
  id: virtual_sink
  parameters:
    stream_id: mcs_control
  states: {state: disabled}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: recv_data
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: mcs_control
  states: {state: disabled}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: rx_signal
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_patterned_interleaver_0, '0']
- [analog_fastnoise_source_x_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_add_xx_0, '0', virtual_sink_1, '0']
- [blocks_message_strobe_0, strobe, inatel5g_variable_deframer_cb_0, reset_ber]
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '1']
- [blocks_null_source_1, '0', inatel5g_variable_framer_bc_0, '0']
- [blocks_patterned_interleaver_0, '0', inatel5g_gfdm_waveform_0, '0']
- [blocks_probe_rate_1, rate, blocks_message_debug_0_0, print]
- [blocks_socket_pdu_0, pdus, inatel5g_variable_framer_bc_0, pdus]
- [blocks_vector_source_x_0, '0', blocks_patterned_interleaver_0, '2']
- [deepSnrEstimation_discard_control_0, '0', epy_block_0_2, '0']
- [deepSnrEstimation_discard_control_0, '0', qtgui_const_sink_x_0, '0']
- [epy_block_0_2, '0', qtgui_number_sink_0, '0']
- [epy_block_0_2, '1', qtgui_number_sink_0_0, '0']
- [epy_block_0_2, mcs, virtual_sink_1_0_0, '0']
- [inatel5g_c_equalizer_0, '0', deepSnrEstimation_discard_control_0, '0']
- [inatel5g_c_equalizer_0, '0', inatel5g_variable_deframer_cb_0, '0']
- [inatel5g_c_equalizer_0, channel_est, qtgui_time_sink_x_0_0, in]
- [inatel5g_gfdm_waveform_0, '0', blocks_add_xx_0, '0']
- [inatel5g_gfdm_waveform_0, '0', blocks_probe_rate_1, '0']
- [inatel5g_gfdm_waveform_1, '0', inatel5g_c_equalizer_0, '0']
- [inatel5g_search_header_0, '0', blocks_null_sink_0, '0']
- [inatel5g_search_header_0, pdus, virtual_sink_1_0, '0']
- [inatel5g_variable_deframer_cb_0, '0', inatel5g_search_header_0, '0']
- [inatel5g_variable_deframer_cb_0, rx_status, epy_block_0_2, msg_in]
- [inatel5g_variable_framer_bc_0, '0', blocks_patterned_interleaver_0, '1']
- [inatel5g_variable_framer_bc_0, '0', qtgui_time_sink_x_0, '0']
- [inatel5g_variable_framer_bc_0, '0', virtual_sink_0, '0']
- [virtual_source_0, '0', blocks_socket_pdu_0, pdus]
- [virtual_source_0_0, '0', inatel5g_variable_framer_bc_0, cmd]
- [virtual_source_1, '0', inatel5g_gfdm_waveform_1, '0']

metadata:
  file_format: 1
  grc_version: 3.9.7.0
